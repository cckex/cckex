## kernel-kexfil/src/custom_kernel_module/Kconfig
```kconfig
config CCKEX_MOD
	tristate "Covert Channel Key Exfiltration Framework LKM"
	default m
	depends on MODULES
	help
	  CCKex LKM
```
